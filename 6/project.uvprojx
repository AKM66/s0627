# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP;.\BSP;.\Libraries;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\Keil;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\RVDS\ARM_CM3;.\UserTask;.\MQTTPacket;.\cJSON;.\APP\lcd
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: main.c stm32f10x_it.c data_handler.c
  group Cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group ST_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c
  group APP
    ./APP/: LED.C systick.c beepkey.c dsgshow.c OLED.C Queue.c
  group BSP
    ./BSP/: BSP_DS18B20.c BSP_Delay.c BSP_DebugUART.c BSP_Buzzer.c BSP_DigitalTube.c BSP_Timer.c BSP_UART.c BSP_ESP8266.c esp8266_init.c bsp_key_exti.c BSP_Smoke.c BSP_BH1750.c BSP_MyIIC.c BSP_DHT11.c bsp.c bsp.h
  group FreeRTOS/Source
    ./FreeRTOS/: croutine.c event_groups.c list.c tasks.c queue.c timers.c
  group FreeRTOS/Ports
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group UserTask
    ./UserTask/: UserTask.c
  group MQTTPacket
    ./MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c MQTTPacket.h
    ./MQTTPacket/samples/: pub0sub1.c transport.c
    ./MQTTPacket/: mqtt.h
  group cJSON
    ./cJSON/: cJSON.c
  group APP/lcd
    ./APP/lcd/: lcd.c lcd_init.c
software components: CMSIS:CORE 6.1.0
