# Keil uVision project MQTT.uvprojx, settings and files
target LED_MQTT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Smarthome +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Source;..\Source\Usb\Mass_Storage\inc;..\Source\Usb\STM32_USB-FS-Device_Driver\inc;..\Source\FATFS;..\Source\bsp;..\Source\esp8266;..\Source\app;..\Source\MQTTPacket\src;..\Source\MQTTPacket;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\Source\cJSON;..\Source\bsp\lcd;..\Source\bsp;..\Source\bsp\snow;..\Source\bsp\ledbuzzer;..\Source\bsp\AlarmLamp;..\Source\bsp\temperature;..\Source\bsp\dht11;..\Source\bsp\BH1750;..\Source\bsp\Smoke
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group BSP
    ../Source/bsp/: bsp_config.h bsp.h bsp.c delay.c BSP_Delay.c BSP_DS18B20.c BSP_DigitalTube.c BSP_Timer.c BSP_OLED.c
    ../Source/bsp/printf/: bsp_printf.c
    ../Source/bsp/key/: bsp_key_exti.c
    ../Source/bsp/led/: bsp_led.c
    ../Source/bsp/gpio/: bsp_gpio.c bsp_gpio.h
    ../Source/bsp/dwt/: bsp_dwt.c
    ../Source/bsp/usart/: bsp_usart1.c BSP_USART3.c
    ../Source/bsp/ledbuzzer/: BSP_LEDBuzzer.c
    ../Source/bsp/Smoke/: BSP_Smoke.c
    ../Source/: BSP_Tracking.c
  group ESP8266
    ../Source/esp8266/: esp8266_init.c esp8266_handler.c
  group MQTT
    ../Source/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../Source/MQTTPacket/samples/: pub0sub1.c transport.c
    ../Source/MQTTPacket/: mqtt.h
  group USER
    ../Source/: main.h main.c stm32f10x_it.c data_handler.c
    ../Source/app/: app_config.h
  group cJSON
    ../Source/cJSON/: cJSON.c
